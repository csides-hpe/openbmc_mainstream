FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-entity-manager-config-for-hpe-s-dl360-poc.patch file://0002-DL360-config-and-early-managed-FRU-handling.patch"


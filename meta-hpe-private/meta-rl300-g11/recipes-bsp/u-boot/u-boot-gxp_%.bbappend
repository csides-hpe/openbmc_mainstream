UBOOT_MACHINE = "gxp_defconfig"


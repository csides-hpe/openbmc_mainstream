RDEPENDS_${PN}-system_remove += "host-boot-enable"

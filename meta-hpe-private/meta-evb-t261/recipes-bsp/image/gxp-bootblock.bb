inherit gxp2-bootblock-t261

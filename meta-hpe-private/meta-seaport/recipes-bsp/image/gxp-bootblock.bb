inherit gxp-bootblock-seaport

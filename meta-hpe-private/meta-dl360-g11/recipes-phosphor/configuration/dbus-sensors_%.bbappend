PACKAGECONFIG:dl360-g11 = " \
			fansensor \
			hwmontempsensor \
                        "
